## BTTM/bootloader/Kconfig.projbuild
```kconfig
menu "Bootloader Brownout Fix"

config BOOTLOADER_BROWNOUT_DETECTOR
    bool "Brownout detector"
    default n

endmenu
```
